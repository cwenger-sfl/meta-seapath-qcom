# QCOM supplies seapath-tune; keep the generic guest image layer independent.
IMAGE_INSTALL:append = " seapath-tune"
