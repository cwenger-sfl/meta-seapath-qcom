# Copyright (C) 2026 Savoir-faire Linux, Inc.
# SPDX-License-Identifier: Apache-2.0

require recipes-core/images/core-image-minimal.bb

DESCRIPTION = "A minimal image that is compatible with SEAPATH PAM policy"
LICENSE = "Apache-2.0"

EXTRA_IMAGE_FEATURES = ""
