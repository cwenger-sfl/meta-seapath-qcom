# Copyright (C) 2026 Savoir-faire Linux, Inc.
# SPDX-License-Identifier: Apache-2.0

PACKAGECONFIG:remove:qcom = "gtk+"
