# Copyright (C) 2026 Savoir-faire Linux, Inc.
# SPDX-License-Identifier: Apache-2.0

# Fix errors when not set
INITRAMFS_IMAGE ?= ''
